VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

UNITS
  DATABASE MICRONS 2000 ;
END UNITS

LAYER metal1
  TYPE ROUTING ;
  DIRECTION HORIZONTAL ;
  PITCH 0.34 ;
  WIDTH 0.17 ;
  SPACING 0.17 ;
END metal1

LAYER via1
  TYPE CUT ;
END via1

SITE unit
  CLASS CORE ;
  SYMMETRY y ;
  SIZE 0.34 BY 1.0 ;
END unit

END LIBRARY
